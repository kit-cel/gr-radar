<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>discarded_carriers</value></param>
<param><key>value</key><value>[]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>v_max</value></param>
<param><key>value</key><value>2000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>R_max</value></param>
<param><key>value</key><value>3e8/2/samp_rate*fft_len</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>transpose_len</value></param>
<param><key>value</key><value>int(np.ceil(packet_len*4.0/len(occupied_carriers_all[0])))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>value</key><value>2**6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>5000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>occupied_carriers</value></param>
<param><key>value</key><value>(range(-26, -21) + range(-20, -7) + range(-6, 0) + range(1, 7) + range(8, 21) + range(22, 27),)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot_carriers</value></param>
<param><key>value</key><value>((-21, -7, 7, 21,),)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_word2</value></param>
<param><key>value</key><value>[0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, -1, 1, -1, -1, 1, -1, 0, 1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, -1, -1, 0, 0, 0, 0, 0] </value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_word1</value></param>
<param><key>value</key><value>[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pilot_symbols</value></param>
<param><key>value</key><value>((1, 1, 1, -1,),)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>payload_mod</value></param>
<param><key>value</key><value>digital.constellation_qpsk()</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>2.45e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>length_tag_key</value></param>
<param><key>value</key><value>"packet_len"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packet_len</value></param>
<param><key>value</key><value>2**9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>zeropadding_fac</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>occupied_carriers_all</value></param>
<param><key>value</key><value>(range(-26,27),)</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>255</value></param>
<param><key>num_samps</key><value>1000</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>packet_len</key><value>packet_len</value></param>
<param><key>len_tag_key</key><value>length_tag_key</value></param>
</block>
<block>
<key>digital_ofdm_cyclic_prefixer</key>
<param><key>id</key><value>digital_ofdm_cyclic_prefixer_0</value></param>
<param><key>input_size</key><value>fft_len</value></param>
<param><key>cp_len</key><value>fft_len/4</value></param>
<param><key>tagname</key><value>length_tag_key</value></param>
<param><key>minoutbuf</key><value>2*transpose_len*(fft_len+fft_len/4)</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>fft_len</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>window</key><value>()</value></param>
<param><key>shift</key><value>True</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0_0</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>payload_mod.points()</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>minoutbuf</key><value>2*packet_len*4</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>payload_mod.bits_per_symbol()</value></param>
<param><key>len_tag_key</key><value>length_tag_key</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>fft_len</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>window</key><value>()</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>minoutbuf</key><value>2*transpose_len</value></param>
</block>
<block>
<key>digital_ofdm_carrier_allocator_cvc</key>
<param><key>id</key><value>digital_ofdm_carrier_allocator_cvc_0</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
<param><key>occupied_carriers</key><value>occupied_carriers_all</value></param>
<param><key>pilot_carriers</key><value>((),)</value></param>
<param><key>pilot_symbols</key><value>((),)</value></param>
<param><key>sync_words</key><value>()</value></param>
<param><key>len_tag_key</key><value>length_tag_key</value></param>
<param><key>minoutbuf</key><value>2*transpose_len</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Range</value></param>
<param><key>label</key><value>Range</value></param>
<param><key>value</key><value>100</value></param>
<param><key>start</key><value>0.1</value></param>
<param><key>stop</key><value>R_max</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>0,0</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fft_len*2</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>velocity</value></param>
<param><key>label</key><value>Velocity</value></param>
<param><key>value</key><value>500</value></param>
<param><key>start</key><value>-v_max</value></param>
<param><key>stop</key><value>v_max</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>0,1</value></param>
</block>
<block>
<key>radar_ofdm_cyclic_prefix_remover_cvc</key>
<param><key>id</key><value>radar_ofdm_cyclic_prefix_remover_cvc_0</value></param>
<param><key>fft_len</key><value>fft_len</value></param>
<param><key>cp_len</key><value>fft_len/4</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>minoutbuf</key><value>2*transpose_len</value></param>
</block>
<block>
<key>radar_static_target_simulator_cc</key>
<param><key>id</key><value>radar_static_target_simulator_cc_0</value></param>
<param><key>range</key><value>Range</value></param>
<param><key>velocity</key><value>velocity</value></param>
<param><key>rcs</key><value>1e25</value></param>
<param><key>azimuth</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq</key><value>center_freq</value></param>
<param><key>self_coupling_db</key><value>-10</value></param>
<param><key>rndm_phaseshift</key><value>True</value></param>
<param><key>self_coupling</key><value>True</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>minoutbuf</key><value>2*transpose_len*(fft_len+fft_len/4)</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>amp</key><value>0.1</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>radar_print_results</key>
<param><key>id</key><value>radar_print_results_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>store_msg</key><value>False</value></param>
</block>
<block>
<key>radar_print_results</key>
<param><key>id</key><value>radar_print_results_0</value></param>
<param><key>store_msg</key><value>False</value></param>
</block>
<block>
<key>radar_estimator_ofdm</key>
<param><key>id</key><value>radar_estimator_ofdm_0</value></param>
<param><key>symbol_x</key><value>'range'</value></param>
<param><key>len_x</key><value>fft_len*zeropadding_fac</value></param>
<param><key>axis_x</key><value>0,R_max</value></param>
<param><key>symbol_y</key><value>'velocity'</value></param>
<param><key>len_y</key><value>transpose_len</value></param>
<param><key>axis_y</key><value>0,v_max,-v_max,0</value></param>
<param><key>merge_consecutive</key><value>True</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>radar_ofdm_divide_vcvc</key>
<param><key>id</key><value>radar_ofdm_divide_vcvc_0</value></param>
<param><key>vlen_in</key><value>fft_len</value></param>
<param><key>vlen_out</key><value>(fft_len-len(discarded_carriers))*zeropadding_fac</value></param>
<param><key>discarded_carriers</key><value>discarded_carriers</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>minoutbuf</key><value>2*transpose_len</value></param>
</block>
<block>
<key>radar_transpose_matrix_vcvc</key>
<param><key>id</key><value>radar_transpose_matrix_vcvc_0</value></param>
<param><key>vlen_in</key><value>(fft_len-len(discarded_carriers))*zeropadding_fac</value></param>
<param><key>vlen_out</key><value>transpose_len</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>minoutbuf</key><value>2*fft_len*zeropadding_fac</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>(fft_len-len(discarded_carriers))*zeropadding_fac</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(fft_len*zeropadding_fac)</value></param>
<param><key>shift</key><value>False</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0_1_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>transpose_len</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>window</key><value>window.blackmanharris(transpose_len)</value></param>
<param><key>shift</key><value>False</value></param>
</block>
<block>
<key>radar_transpose_matrix_vcvc</key>
<param><key>id</key><value>radar_transpose_matrix_vcvc_0_0</value></param>
<param><key>vlen_in</key><value>transpose_len</value></param>
<param><key>vlen_out</key><value>(fft_len-len(discarded_carriers))*zeropadding_fac</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>minoutbuf</key><value>2*transpose_len</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>vlen</key><value>(fft_len-len(discarded_carriers))*zeropadding_fac</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>n</key><value>1</value></param>
<param><key>k</key><value>0</value></param>
<param><key>vlen</key><value>(fft_len-len(discarded_carriers))*zeropadding_fac</value></param>
</block>
<block>
<key>radar_os_cfar_2d_vc</key>
<param><key>id</key><value>radar_os_cfar_2d_vc_0</value></param>
<param><key>vlen</key><value>(fft_len-len(discarded_carriers))*zeropadding_fac</value></param>
<param><key>samp_compare</key><value>10,10</value></param>
<param><key>samp_protect</key><value>0,0</value></param>
<param><key>rel_threshold</key><value>0.78</value></param>
<param><key>mult_threshold</key><value>30</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
</block>
<block>
<key>radar_qtgui_spectrogram_plot</key>
<param><key>id</key><value>radar_qtgui_spectrogram_plot_0</value></param>
<param><key>vlen</key><value>(fft_len-len(discarded_carriers))*zeropadding_fac</value></param>
<param><key>interval</key><value>500</value></param>
<param><key>xlabel</key><value>'Range'</value></param>
<param><key>ylabel</key><value>'Velocity'</value></param>
<param><key>label</key><value>'OFDM Radar'</value></param>
<param><key>axis_x</key><value>0,R_max</value></param>
<param><key>axis_y</key><value>0,v_max</value></param>
<param><key>axis_z</key><value>-15,-12</value></param>
<param><key>autoscale_z</key><value>True</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>(fft_len-len(discarded_carriers))*zeropadding_fac</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<connection><source_block_id>digital_ofdm_cyclic_prefixer_0</source_block_id><sink_block_id>radar_static_target_simulator_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0_0</source_block_id><sink_block_id>digital_ofdm_carrier_allocator_cvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_ofdm_cyclic_prefix_remover_cvc_0</source_block_id><sink_block_id>fft_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0_1</source_block_id><sink_block_id>radar_transpose_matrix_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_transpose_matrix_vcvc_0</source_block_id><sink_block_id>fft_vxx_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0_1_0</source_block_id><sink_block_id>radar_transpose_matrix_vcvc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>digital_ofdm_cyclic_prefixer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>radar_ofdm_cyclic_prefix_remover_cvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_static_target_simulator_cc_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>radar_qtgui_spectrogram_plot_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_transpose_matrix_vcvc_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_carrier_allocator_cvc_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_ofdm_divide_vcvc_0</source_block_id><sink_block_id>fft_vxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0_0</source_block_id><sink_block_id>radar_ofdm_divide_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digital_ofdm_carrier_allocator_cvc_0</source_block_id><sink_block_id>radar_ofdm_divide_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_transpose_matrix_vcvc_0_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_transpose_matrix_vcvc_0_0</source_block_id><sink_block_id>radar_os_cfar_2d_vc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_estimator_ofdm_0</source_block_id><sink_block_id>radar_print_results_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in</sink_key></connection>
<connection><source_block_id>radar_os_cfar_2d_vc_0</source_block_id><sink_block_id>radar_estimator_ofdm_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in</sink_key></connection>
<connection><source_block_id>radar_os_cfar_2d_vc_0</source_block_id><sink_block_id>radar_print_results_0_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
