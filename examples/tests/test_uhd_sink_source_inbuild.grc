<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>10000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>min_output_buffer</value></param>
<param><key>value</key><value>packet_len*2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>5800000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packet_len</value></param>
<param><key>value</key><value>2**12</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_res</value></param>
<param><key>value</key><value>samp_rate/packet_len</value></param>
</block>
<block>
<key>radar_os_cfar_c</key>
<param><key>id</key><value>radar_os_cfar_c_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>samp_compare</key><value>15</value></param>
<param><key>samp_protect</key><value>0</value></param>
<param><key>rel_threshold</key><value>0.78</value></param>
<param><key>mult_threshold</key><value>15</value></param>
<param><key>merge_consecutive</key><value>True</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>packet_len</key><value>packet_len</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>fftsize</key><value>packet_len</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>freqchangevar</key><value>None</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>50000</value></param>
<param><key>amp</key><value>0.5</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>packet_len</key><value>packet_len</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
</block>
<block>
<key>radar_usrp_echotimer_cc</key>
<param><key>id</key><value>radar_usrp_echotimer_cc_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>n_outputs</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq</key><value>center_freq</value></param>
<param><key>num_delay_samps</key><value>(0,)</value></param>
<param><key>wire_tx</key><value></value></param>
<param><key>clock_source_tx</key><value></value></param>
<param><key>time_source_tx</key><value></value></param>
<param><key>timeout_tx</key><value>0.05</value></param>
<param><key>wait_tx</key><value></value></param>
<param><key>lo_offset_tx</key><value></value></param>
<param><key>args_rx</key><value></value></param>
<param><key>wire_rx</key><value></value></param>
<param><key>clock_source_rx</key><value></value></param>
<param><key>time_source_rx</key><value></value></param>
<param><key>timeout_rx</key><value></value></param>
<param><key>wait_rx</key><value></value></param>
<param><key>lo_offset_rx</key><value></value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<block>
<key>radar_ts_fft_cc</key>
<param><key>id</key><value>radar_ts_fft_cc_0</value></param>
<param><key>packet_len</key><value>packet_len</value></param>
<param><key>len_key</key><value> "packet_len"</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
</block>
<block>
<key>radar_print_peaks</key>
<param><key>id</key><value>radar_print_peaks_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>'addr=192.168.10.6'</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>clock_source0</key><value>gpsdo</value></param>
<param><key>time_source0</key><value>gpsdo</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>center_freq</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>ant0</key><value>"J1"</value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>"addr=192.168.10.4"</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>clock_source0</key><value>gpsdo</value></param>
<param><key>time_source0</key><value>gpsdo</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>center_freq</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>ant0</key><value>"J1"</value></param>
</block>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_os_cfar_c_0</source_block_id><sink_block_id>radar_print_peaks_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in</sink_key></connection>
<connection><source_block_id>radar_ts_fft_cc_0</source_block_id><sink_block_id>radar_os_cfar_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>radar_ts_fft_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_usrp_echotimer_cc_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_1</source_block_id><sink_block_id>radar_usrp_echotimer_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
