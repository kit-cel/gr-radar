options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: test_split_cc
    output_language: python
  states: {}

blocks:
- name: samp_cw
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: samp_down
  id: variable
  parameters:
    value: '512'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: samp_up
  id: variable
  parameters:
    value: '512'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    update_time: 1/15
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: radar_signal_generator_fmcw_c_0
  id: radar_signal_generator_fmcw_c
  parameters:
    amplitude: '1'
    freq_cw: '0'
    freq_sweep: '250'
    len_key: '"packet_len"'
    samp_cw: samp_cw
    samp_down: samp_down
    samp_rate: samp_rate
    samp_up: samp_up
  states: {}
- name: radar_split_cc_0
  id: radar_split_cc
  parameters:
    len_key: '"packet_len"'
    packet_num: '0'
    packet_parts: (samp_cw, samp_up, samp_down)
  states: {}
- name: radar_split_cc_0_0
  id: radar_split_cc
  parameters:
    len_key: '"packet_len"'
    packet_num: '1'
    packet_parts: (samp_cw, samp_up, samp_down)
  states: {}
- name: radar_split_cc_0_1
  id: radar_split_cc
  parameters:
    len_key: '"packet_len"'
    packet_num: '2'
    packet_parts: (samp_cw, samp_up, samp_down)
  states: {}
- name: radar_static_target_simulator_cc_0
  id: radar_static_target_simulator_cc
  parameters:
    azimuth: '0'
    center_freq: 2.4e9
    len_key: '"packet_len"'
    position_rx: '0'
    range: '10'
    rcs: 1e12
    rndm_phaseshift: 'True'
    samp_rate: samp_rate
    self_coupling: 'True'
    self_coupling_db: '-10'
    velocity: '5'
  states: {}

connections:
- [blocks_multiply_xx_0, '0', radar_split_cc_0, '0']
- [blocks_multiply_xx_0, '0', radar_split_cc_0_0, '0']
- [blocks_multiply_xx_0, '0', radar_split_cc_0_1, '0']
- [blocks_throttle_0, '0', blocks_multiply_xx_0, '1']
- [radar_signal_generator_fmcw_c_0, '0', blocks_throttle_0, '0']
- [radar_signal_generator_fmcw_c_0, '0', radar_static_target_simulator_cc_0, '0']
- [radar_split_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [radar_split_cc_0_0, '0', blocks_null_sink_0, '0']
- [radar_split_cc_0_1, '0', blocks_null_sink_1, '0']
- [radar_static_target_simulator_cc_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
