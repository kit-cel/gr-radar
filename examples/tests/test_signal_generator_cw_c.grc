options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: test_signal_generator_cw_c
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000'
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: radar_signal_generator_cw_c_0
  id: radar_signal_generator_cw_c
  parameters:
    amplitude: '1'
    frequency: '500'
    len_key: '"packet_len"'
    packet_len: '1024'
    samp_rate: samp_rate
  states: {}

connections:
- [blocks_throttle_0, '0', blocks_tag_debug_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [radar_signal_generator_cw_c_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
