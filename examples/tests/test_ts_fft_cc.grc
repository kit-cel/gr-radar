options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: test_ts_fft_cc
    output_language: python
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-samp_rate/2.0'
    step: '1'
    stop: samp_rate/2.0
    value: '1000'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: 2**11
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: packet_len
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: packet_len
    name: TS FFT
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: radar_find_max_peak_c_0_0
  id: radar_find_max_peak_c
  parameters:
    cut_max_freq: 'False'
    len_key: '"packet_len"'
    max_freq: '[]'
    samp_protect: '0'
    samp_rate: samp_rate
    threshold: '-200'
  states: {}
- name: radar_print_results_0
  id: radar_print_results
  parameters:
    store_msg: 'False'
  states: {}
- name: radar_ts_fft_cc_0
  id: radar_ts_fft_cc
  parameters:
    len_key: ' "packet_len"'
    packet_len: packet_len
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', radar_ts_fft_cc_0, '0']
- [blocks_throttle_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [radar_find_max_peak_c_0_0, Msg out, radar_print_results_0, Msg in]
- [radar_ts_fft_cc_0, '0', radar_find_max_peak_c_0_0, '0']

metadata:
  file_format: 1
