options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: test_signal_generator_fmcw_c
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: radar_signal_generator_fmcw_c_0
  id: radar_signal_generator_fmcw_c
  parameters:
    amplitude: '1'
    freq_cw: '200'
    freq_sweep: '600'
    len_key: '"packet_len"'
    samp_cw: '10000'
    samp_down: '10000'
    samp_rate: samp_rate
    samp_up: '10000'
  states: {}

connections:
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [radar_signal_generator_fmcw_c_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
