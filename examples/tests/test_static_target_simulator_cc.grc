options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: test_static_target_simulator_cc
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 5.7e9
  states: {}
- name: doppler_ref
  id: variable
  parameters:
    value: 2*v*center_freq/3e8
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: shift
  id: variable
  parameters:
    value: '0.25'
  states: {}
- name: v
  id: variable
  parameters:
    value: '100'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_imag_1
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '1000'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '1000'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    name: '"Doppler"'
    type: complex
    update_time: 1/15
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Real"'
    nconnections: '2'
    size: '200'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Imag"'
    nconnections: '2'
    size: '200'
    srate: samp_rate
    type: float
  states: {}
- name: radar_static_target_simulator_cc_0
  id: radar_static_target_simulator_cc
  parameters:
    azimuth: '0'
    center_freq: center_freq
    len_key: '"packet_len"'
    position_rx: '0'
    range: shift*32*3e8/2/samp_rate
    rcs: 5*1e23
    rndm_phaseshift: 'True'
    samp_rate: samp_rate
    self_coupling: 'True'
    self_coupling_db: '-10'
    velocity: '0'
  states: {}
- name: radar_static_target_simulator_cc_0_0
  id: radar_static_target_simulator_cc
  parameters:
    azimuth: '0'
    center_freq: center_freq
    len_key: '"packet_len"'
    position_rx: '0'
    range: 32*3e8/2/samp_rate
    rcs: 5*1e23
    rndm_phaseshift: 'True'
    samp_rate: samp_rate
    self_coupling: 'True'
    self_coupling_db: '-10'
    velocity: v
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_throttle_0_0, '0']
- [blocks_complex_to_imag_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_imag_1, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_real_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_stream_to_tagged_stream_0, '0', radar_static_target_simulator_cc_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', radar_static_target_simulator_cc_0_0, '0']
- [blocks_throttle_0, '0', blocks_complex_to_imag_1, '0']
- [blocks_throttle_0, '0', blocks_complex_to_real_0, '0']
- [blocks_throttle_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_throttle_0_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [radar_static_target_simulator_cc_0, '0', blocks_complex_to_imag_0, '0']
- [radar_static_target_simulator_cc_0, '0', blocks_complex_to_real_0_0, '0']
- [radar_static_target_simulator_cc_0_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
