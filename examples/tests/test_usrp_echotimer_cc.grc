<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>wait_to_start</value></param>
<param><key>value</key><value>0.05</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packet_len</value></param>
<param><key>value</key><value>2**16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>5800000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_res</value></param>
<param><key>value</key><value>samp_rate/packet_len</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packet_len_red</value></param>
<param><key>value</key><value>packet_len/decim_fac</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim_fac</value></param>
<param><key>value</key><value>2**2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>min_output_buffer</value></param>
<param><key>value</key><value>packet_len*2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>250000</value></param>
</block>
<block>
<key>radar_estimator_cw</key>
<param><key>id</key><value>radar_estimator_cw_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>center_freq</key><value>center_freq</value></param>
</block>
<block>
<key>radar_print_results</key>
<param><key>id</key><value>radar_print_results_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>fftsize</key><value>packet_len/decim_fac</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>samp_rate/decim_fac</value></param>
<param><key>freqchangevar</key><value>None</value></param>
</block>
<block>
<key>radar_print_peaks</key>
<param><key>id</key><value>radar_print_peaks_0</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>"addr=192.168.10.6"</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>clock_source0</key><value>internal</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>0</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>ant0</key><value>"J1"</value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>radar_signal_generator_fmcw_c</key>
<param><key>id</key><value>radar_signal_generator_fmcw_c_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>samp_cw</key><value>0</value></param>
<param><key>samp_up</key><value>packet_len</value></param>
<param><key>samp_down</key><value>0</value></param>
<param><key>freq_cw</key><value>50000</value></param>
<param><key>freq_sweep</key><value>10000</value></param>
<param><key>amplitude</key><value>0.5</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
</block>
<block>
<key>radar_os_cfar_c</key>
<param><key>id</key><value>radar_os_cfar_c_0</value></param>
<param><key>samp_rate</key><value>samp_rate/decim_fac</value></param>
<param><key>samp_compare</key><value>15</value></param>
<param><key>samp_protect</key><value>0</value></param>
<param><key>rel_threshold</key><value>0.78</value></param>
<param><key>mult_threshold</key><value>15</value></param>
<param><key>merge_consecutive</key><value>True</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
</block>
<block>
<key>blocks_tagged_stream_multiply_length</key>
<param><key>id</key><value>blocks_tagged_stream_multiply_length_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>lengthtagname</key><value>"packet_len"</value></param>
<param><key>c</key><value>1.0/decim_fac</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
</block>
<block>
<key>ts_fft_py_cc</key>
<param><key>id</key><value>ts_fft_py_cc_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>samp_rate</key><value>samp_rate/decim_fac</value></param>
<param><key>packet_len</key><value>packet_len/decim_fac</value></param>
</block>
<block>
<key>radar_ts_fft_cc</key>
<param><key>id</key><value>radar_ts_fft_cc_0</value></param>
<param><key>apply_filter</key><value>0</value></param>
<param><key>len_key</key><value> "packet_len"</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>decim</key><value>decim_fac</value></param>
<param><key>taps</key><value></value></param>
</block>
<block>
<key>radar_signal_generator_cw_c</key>
<param><key>id</key><value>radar_signal_generator_cw_c_0</value></param>
<param><key>packet_len</key><value>packet_len</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>frequency</key><value>10000</value></param>
<param><key>amplitude</key><value>0.5</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>num_delay_samps</value></param>
<param><key>value</key><value>0</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>1000</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>radar_usrp_echotimer_cc</key>
<param><key>id</key><value>radar_usrp_echotimer_cc_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq</key><value>center_freq</value></param>
<param><key>num_delay_samps</key><value>int(num_delay_samps)</value></param>
<param><key>args_tx</key><value>'addr=192.168.10.6'</value></param>
<param><key>antenna_tx</key><value>'J1'</value></param>
<param><key>wait_tx</key><value>wait_to_start</value></param>
<param><key>args_rx</key><value>'addr=192.168.10.4'</value></param>
<param><key>antenna_rx</key><value>'J1'</value></param>
<param><key>wait_rx</key><value>wait_to_start</value></param>
<param><key>lo_offset_rx</key><value>samp_rate/2</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
</block>
<connection><source_block_id>radar_os_cfar_c_0</source_block_id><sink_block_id>radar_print_peaks_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in</sink_key></connection>
<connection><source_block_id>radar_os_cfar_c_0</source_block_id><sink_block_id>radar_estimator_cw_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in</sink_key></connection>
<connection><source_block_id>radar_estimator_cw_0</source_block_id><sink_block_id>radar_print_results_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_multiply_length_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_signal_generator_cw_c_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_tagged_stream_multiply_length_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_multiply_length_0</source_block_id><sink_block_id>ts_fft_py_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ts_fft_py_cc_0</source_block_id><sink_block_id>radar_os_cfar_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_ts_fft_cc_0</source_block_id><sink_block_id>radar_os_cfar_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_multiply_length_0</source_block_id><sink_block_id>radar_ts_fft_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_signal_generator_cw_c_0</source_block_id><sink_block_id>radar_usrp_echotimer_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_usrp_echotimer_cc_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
