<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>wait_to_start</value></param>
<param><key>value</key><value>0.02</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packet_len</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>send_samp</value></param>
<param><key>value</key><value>100,200,50</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>wait_samp</value></param>
<param><key>value</key><value>100,50,100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>250000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>min_output_buffer</value></param>
<param><key>value</key><value>packet_len*2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>2400000000</value></param>
</block>
<block>
<key>radar_usrp_echotimer_cc</key>
<param><key>id</key><value>radar_usrp_echotimer_cc_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq</key><value>center_freq</value></param>
<param><key>num_delay_samps</key><value>int(num_delay_samp)</value></param>
<param><key>args_tx</key><value>'addr=192.168.10.6'</value></param>
<param><key>antenna_tx</key><value>'J1'</value></param>
<param><key>gain_tx</key><value>10</value></param>
<param><key>wait_tx</key><value>wait_to_start</value></param>
<param><key>args_rx</key><value>'addr=192.168.10.4'</value></param>
<param><key>antenna_rx</key><value>'J1'</value></param>
<param><key>gain_rx</key><value>20</value></param>
<param><key>wait_rx</key><value>wait_to_start</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
</block>
<block>
<key>radar_signal_generator_sync_pulse_c</key>
<param><key>id</key><value>radar_signal_generator_sync_pulse_c_0</value></param>
<param><key>packet_len</key><value>packet_len</value></param>
<param><key>pulse_len</key><value>wait_samp</value></param>
<param><key>pulse_pause</key><value>send_samp</value></param>
<param><key>pulse_amplitude</key><value>0.5</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
</block>
<block>
<key>radar_print_results</key>
<param><key>id</key><value>radar_print_results_0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>num_delay_samp</value></param>
<param><key>value</key><value>0</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>packet_len</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>radar_estimator_sync_pulse_c</key>
<param><key>id</key><value>radar_estimator_sync_pulse_c_0</value></param>
<param><key>num_xcorr</key><value>int(num_corr)</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>num_corr</value></param>
<param><key>value</key><value>0</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>packet_len</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<connection><source_block_id>radar_signal_generator_sync_pulse_c_0</source_block_id><sink_block_id>radar_usrp_echotimer_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_usrp_echotimer_cc_0</source_block_id><sink_block_id>radar_estimator_sync_pulse_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_signal_generator_sync_pulse_c_0</source_block_id><sink_block_id>radar_estimator_sync_pulse_c_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>radar_estimator_sync_pulse_c_0</source_block_id><sink_block_id>radar_print_results_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in</sink_key></connection>
</flow_graph>
