<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim_fac</value></param>
<param><key>value</key><value>2**8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>block_per_tag</value></param>
<param><key>value</key><value>2**17</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>range_time</value></param>
<param><key>value</key><value>30</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>wait_to_start</value></param>
<param><key>value</key><value>0.02</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_red</value></param>
<param><key>value</key><value>samp_rate/2/samp_per_freq/decim_fac</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>delta_freq</value></param>
<param><key>value</key><value>1.25e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vel_res</value></param>
<param><key>value</key><value>freq_res/2.0/center_freq*3e8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>measure_time</value></param>
<param><key>value</key><value>(block_per_tag*samp_per_freq*2)/float(samp_rate)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_res</value></param>
<param><key>value</key><value>samp_rate_red/packet_len_red</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>range_res</value></param>
<param><key>value</key><value>3e8/2/delta_freq</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>2450000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>min_output_buffer</value></param>
<param><key>value</key><value>2*samp_per_freq*block_per_tag*2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_per_freq</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packet_len_red</value></param>
<param><key>value</key><value>block_per_tag/decim_fac</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>decim</key><value>decim_fac</value></param>
<param><key>taps</key><value></value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain_tx</value></param>
<param><key>label</key><value>TX gain</value></param>
<param><key>value</key><value>10</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>0,0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain_rx</value></param>
<param><key>label</key><value>RX gain</value></param>
<param><key>value</key><value>10</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>0,1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>samp_protect</value></param>
<param><key>label</key><value>Find peak protected samples</value></param>
<param><key>value</key><value>3</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>1,1</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>decim</key><value>decim_fac</value></param>
<param><key>taps</key><value></value></param>
</block>
<block>
<key>radar_find_max_peak_c</key>
<param><key>id</key><value>radar_find_max_peak_c_0</value></param>
<param><key>samp_rate</key><value>samp_rate_red</value></param>
<param><key>threshold</key><value>threshold</value></param>
<param><key>samp_protect</key><value>int(samp_protect)</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>delay_samp</value></param>
<param><key>label</key><value>Number delay samples</value></param>
<param><key>value</key><value>24</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>fftsize</key><value>packet_len_red</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>samp_rate_red</value></param>
<param><key>freqchangevar</key><value>None</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
</block>
<block>
<key>radar_split_fsk_cc</key>
<param><key>id</key><value>radar_split_fsk_cc_0</value></param>
<param><key>samp_per_freq</key><value>samp_per_freq</value></param>
<param><key>samp_discard</key><value>samp_per_freq-1</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>minoutbuf</key><value>min_output_buffer//2</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>threshold</value></param>
<param><key>label</key><value>Find peak threshold</value></param>
<param><key>value</key><value>-75</value></param>
<param><key>start</key><value>-200</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>1,0</value></param>
</block>
<block>
<key>radar_signal_generator_fsk_c</key>
<param><key>id</key><value>radar_signal_generator_fsk_c_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>samp_per_freq</key><value>samp_per_freq</value></param>
<param><key>blocks_per_tag</key><value>block_per_tag</value></param>
<param><key>freq_low</key><value>-delta_freq/2</value></param>
<param><key>freq_high</key><value>delta_freq/2</value></param>
<param><key>amplitude</key><value>0.5</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
</block>
<block>
<key>radar_qtgui_time_plot</key>
<param><key>id</key><value>radar_qtgui_time_plot_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>interval</key><value>100</value></param>
<param><key>label_y</key><value>'range'</value></param>
<param><key>axis_y</key><value>0,6</value></param>
<param><key>range_time</key><value>range_time</value></param>
<param><key>label</key><value>"MAX RANGE"</value></param>
</block>
<block>
<key>radar_usrp_echotimer_cc</key>
<param><key>id</key><value>radar_usrp_echotimer_cc_0</value></param>
<param><key>n_outputs</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq</key><value>center_freq</value></param>
<param><key>num_delay_samps</key><value>(int(delay_samp),)</value></param>
<param><key>args_tx</key><value>'addr=192.168.10.4'</value></param>
<param><key>antenna_tx</key><value>'J1'</value></param>
<param><key>gain_tx</key><value>gain_tx</value></param>
<param><key>wait_tx</key><value>wait_to_start</value></param>
<param><key>args_rx</key><value>('addr=192.168.10.6',)</value></param>
<param><key>wire_rx</key><value>('',)</value></param>
<param><key>clock_source_rx</key><value>('mimo',)</value></param>
<param><key>time_source_rx</key><value>('mimo',)</value></param>
<param><key>antenna_rx</key><value>('J1',)</value></param>
<param><key>gain_rx</key><value>(gain_rx,)</value></param>
<param><key>timeout_rx</key><value>(0.1,)</value></param>
<param><key>wait_rx</key><value>(wait_to_start,)</value></param>
<param><key>lo_offset_rx</key><value>(0,)</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
</block>
<block>
<key>radar_qtgui_scatter_plot</key>
<param><key>id</key><value>radar_qtgui_scatter_plot_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>interval</key><value>250</value></param>
<param><key>label_x</key><value>'range'</value></param>
<param><key>label_y</key><value>'velocity'</value></param>
<param><key>axis_x</key><value>0,15</value></param>
<param><key>axis_y</key><value>-3,3</value></param>
</block>
<block>
<key>radar_qtgui_time_plot</key>
<param><key>id</key><value>radar_qtgui_time_plot_0_0</value></param>
<param><key>interval</key><value>100</value></param>
<param><key>label_y</key><value>'range'</value></param>
<param><key>axis_y</key><value>0,15</value></param>
<param><key>range_time</key><value>range_time</value></param>
</block>
<block>
<key>radar_qtgui_time_plot</key>
<param><key>id</key><value>radar_qtgui_time_plot_0</value></param>
<param><key>interval</key><value>100</value></param>
<param><key>label_y</key><value>'velocity'</value></param>
<param><key>axis_y</key><value>-3,3</value></param>
<param><key>range_time</key><value>range_time</value></param>
</block>
<block>
<key>radar_print_results</key>
<param><key>id</key><value>radar_print_results_1</value></param>
<param><key>store_msg</key><value>False</value></param>
<param><key>filename</key><value>"store_msgs.txt"</value></param>
</block>
<block>
<key>radar_estimator_fsk</key>
<param><key>id</key><value>radar_estimator_fsk_0</value></param>
<param><key>center_freq</key><value>center_freq</value></param>
<param><key>delta_freq</key><value>delta_freq/2</value></param>
</block>
<block>
<key>radar_qtgui_time_plot</key>
<param><key>id</key><value>radar_qtgui_time_plot_0_1</value></param>
<param><key>interval</key><value>100</value></param>
<param><key>label_y</key><value>'velocity'</value></param>
<param><key>axis_y</key><value>-3,3</value></param>
<param><key>range_time</key><value>range_time</value></param>
<param><key>label</key><value>"TRACKING"</value></param>
</block>
<block>
<key>radar_tracking_singletarget</key>
<param><key>id</key><value>radar_tracking_singletarget_0</value></param>
<param><key>num_particle</key><value>500</value></param>
<param><key>std_range_meas</key><value>3</value></param>
<param><key>std_velocity_meas</key><value>0.25</value></param>
<param><key>std_accel_sys</key><value>0.5</value></param>
<param><key>threshold_track</key><value>0.001</value></param>
<param><key>threshold_lost</key><value>1</value></param>
<param><key>filter</key><value>"particle"</value></param>
</block>
<block>
<key>radar_qtgui_time_plot</key>
<param><key>id</key><value>radar_qtgui_time_plot_0_0_1</value></param>
<param><key>interval</key><value>100</value></param>
<param><key>label_y</key><value>'range'</value></param>
<param><key>axis_y</key><value>0,15</value></param>
<param><key>range_time</key><value>range_time</value></param>
<param><key>label</key><value>"TRACKING"</value></param>
</block>
<block>
<key>blocks_tagged_stream_multiply_length</key>
<param><key>id</key><value>blocks_tagged_stream_multiply_length_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>lengthtagname</key><value>"packet_len"</value></param>
<param><key>c</key><value>1/float(decim_fac)</value></param>
<param><key>minoutbuf</key><value>min_output_buffer/samp_per_freq/2/decim_fac</value></param>
</block>
<block>
<key>radar_ts_fft_cc</key>
<param><key>id</key><value>radar_ts_fft_cc_0_0</value></param>
<param><key>packet_len</key><value>packet_len_red</value></param>
<param><key>len_key</key><value> "packet_len"</value></param>
</block>
<block>
<key>blocks_tagged_stream_multiply_length</key>
<param><key>id</key><value>blocks_tagged_stream_multiply_length_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>lengthtagname</key><value>"packet_len"</value></param>
<param><key>c</key><value>1/float(decim_fac)</value></param>
<param><key>minoutbuf</key><value>min_output_buffer/samp_per_freq/2/decim_fac</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_1</value></param>
<param><key>minoutbuf</key><value>min_output_buffer/2/samp_per_freq/decim_fac</value></param>
</block>
<block>
<key>radar_ts_fft_cc</key>
<param><key>id</key><value>radar_ts_fft_cc_0_0_0</value></param>
<param><key>packet_len</key><value>packet_len_red</value></param>
<param><key>len_key</key><value> "packet_len"</value></param>
</block>
<connection><source_block_id>radar_signal_generator_fsk_c_0</source_block_id><sink_block_id>radar_usrp_echotimer_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_tagged_stream_multiply_length_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_1</source_block_id><sink_block_id>radar_find_max_peak_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_find_max_peak_c_0</source_block_id><sink_block_id>radar_estimator_fsk_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>blocks_tagged_stream_multiply_length_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_split_fsk_cc_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_split_fsk_cc_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0</source_block_id><sink_block_id>radar_split_fsk_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_signal_generator_fsk_c_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>radar_usrp_echotimer_cc_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_estimator_fsk_0</source_block_id><sink_block_id>radar_qtgui_time_plot_0_0_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in</sink_key></connection>
<connection><source_block_id>radar_estimator_fsk_0</source_block_id><sink_block_id>radar_qtgui_scatter_plot_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in</sink_key></connection>
<connection><source_block_id>radar_estimator_fsk_0</source_block_id><sink_block_id>radar_print_results_1</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in</sink_key></connection>
<connection><source_block_id>radar_estimator_fsk_0</source_block_id><sink_block_id>radar_qtgui_time_plot_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in</sink_key></connection>
<connection><source_block_id>radar_estimator_fsk_0</source_block_id><sink_block_id>radar_qtgui_time_plot_0_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_multiply_length_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_estimator_fsk_0</source_block_id><sink_block_id>radar_tracking_singletarget_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in</sink_key></connection>
<connection><source_block_id>radar_tracking_singletarget_0</source_block_id><sink_block_id>radar_qtgui_time_plot_0_1</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in</sink_key></connection>
<connection><source_block_id>radar_tracking_singletarget_0</source_block_id><sink_block_id>radar_qtgui_time_plot_0_0_1</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_multiply_length_0</source_block_id><sink_block_id>radar_ts_fft_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_ts_fft_cc_0_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_multiply_length_0_0</source_block_id><sink_block_id>radar_ts_fft_cc_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_ts_fft_cc_0_0_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
